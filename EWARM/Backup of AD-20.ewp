# IAR project Backup of AD-20.ewp, settings and files
configuration AD-20 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER; UNIT_TEST
  ICCARM.CCDiagSuppress: Pe550,Pe177
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ..\cJSON; ..\MQTT; ..\MQTT\MQTTPacket; ..\MQTT\FreeRTOS; ..\w5500\common; ..\w5500\ethernet; ..\w5500\ethernet\socket; ..\w5500\ethernet\socket_bsd; ..\w5500\ethernet\w5500; ..\w5500\host; ..\w5500\internet\DHCP; ..\w5500\internet\DNS; ..\user_app\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: AD-20.hex
  ILINK.IlinkOutputFile: AD-20.out
  ILINK.IlinkIcfFile: AD-20.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c
  group CJSON
    ../cJSON/: cJSON.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group MQTT
    ../MQTT/: MQTTClient.c
    ../MQTT/FreeRTOS/: MQTTFreeRTOS.c
  group MQTT/packet
    ../MQTT/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group USER_APP
    ../user_app/src/: bt.c console.c DataSave.c EC20.c MQTT_Conn.c prjlib.c Process.c rtc_ext.c spi_flash.c system.c uart.c
  group W5500/comon
    ../w5500/common/: common.h util.c util.h
  group W5500/ethernet
    ../w5500/ethernet/: wizchip_conf.c wizchip_conf.h
  group W5500/ethernet/socket
    ../w5500/ethernet/socket/: netctrl.c socket.c sockutil.c
  group W5500/ethernet/socket_bsd
    ../w5500/ethernet/socket_bsd/: socket_bsd.c
  group W5500/ethernet/w5500
    ../w5500/ethernet/w5500/: w5500.c
  group W5500/host
    ../w5500/host/: w5500_comm.c
  group W5500/internet
    ../w5500/internet/DHCP/: dhcp.c
    ../w5500/internet/DNS/: dns.c
